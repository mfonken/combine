# IAR project efr32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG1B232F256GM32 SiliconLaboratories EFR32BG1B232F256GM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GENERATION_DONE; EFR32BG1B232F256GM32
  ICCARM.CCDiagSuppress: pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: C:\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\protocol\bluetooth_2.1\ble_stack\inc\common; C:\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\protocol\bluetooth_2.1\ble_stack\inc\soc; inc; $PROJ_DIR$; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\CMSIS\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\Device\SiliconLabs\EFR32BG1B\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\common\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\dmadrv\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\dmadrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\gpiointerrupt\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\nvm\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\nvm\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\rtcdrv\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\rtcdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\sleep\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\spidrv\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\spidrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\tempdrv\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\tempdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\uartdrv\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\uartdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\ustimer\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emdrv\ustimer\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\emlib\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\hardware\kit\common\bsp; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\hardware\kit\common\drivers; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\platform\radio\rail_lib\chip\efr32\rf\common\cortex
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ble-module.bin
  ILINK.IlinkOutputFile: ble-module.out
  ILINK.IlinkIcfFile: C:\SiliconLabs\SimplicityStudio\v4\developer\stacks\ble\v2.1.1.0\protocol\bluetooth_2.1\ble_stack\linker\bleDemo.icf
  ILINK.IlinkExtraOptions: --keep __iar_program_start; --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  group (top)
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/ble/v2.1.1.0/platform/Device/SiliconLabs/EFR32BG1B/Source/IAR/: startup_efr32bg1b.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/ble/v2.1.1.0/platform/emlib/src/: em_cryotimer.c em_gpio.c em_i2c.c em_msc.c em_rtcc.c em_usart.c
    ./: gatt_db.c main.c
    src/: InitDevice.c
  group gattdb
    ./: gatt.xml
  group include
    C:/SiliconLabs/SimplicityStudio/v4/developer/stacks/ble/v2.1.1.0/protocol/bluetooth_2.1/ble_stack/inc/common/: bg_errorcodes.h bg_gattdb_def.h bg_types.h gecko_configuration.h
    C:/SiliconLabs/SimplicityStudio/v4/developer/stacks/ble/v2.1.1.0/protocol/bluetooth_2.1/ble_stack/inc/soc/: native_gecko.h
  group lib
    C:/SiliconLabs/SimplicityStudio/v4/developer/stacks/ble/v2.1.1.0/protocol/bluetooth_2.1/lib/: binbootloader.o stack.a binstack.o
