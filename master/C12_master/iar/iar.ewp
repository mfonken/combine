# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG13P632F512GM48 SiliconLaboratories EFR32BG13P632F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32BG13P632F512GM48; NVM3_DEFAULT_NVM_SIZE=24576; HAL_CONFIG=1
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: ..; ../.; ../platform\CMSIS\Include; ../platform\radio\rail_lib\common; ../platform\radio\rail_lib\chip\efr32\efr32xg1x; ../platform\radio\rail_lib\protocol\ble; ../platform\radio\rail_lib\protocol\ieee802154; ../hardware\kit\common\drivers; ../hardware\kit\EFR32BG13_BRD4104A\config; ../hardware\kit\common\bsp; ../platform\emlib\inc; ../platform\emdrv\sleep\inc; ../platform\emdrv\common\inc; ../platform\emdrv\uartdrv\inc; ../platform\emdrv\gpiointerrupt\inc; ../platform\emdrv\nvm3\inc; ../platform\Device\SiliconLabs\EFR32BG13P\Include; ../protocol\bluetooth\ble_stack\inc\common; ../protocol\bluetooth\ble_stack\inc\soc; ../platform\common\inc; ../platform\service\sleeptimer\config; ../platform\service\sleeptimer\inc; ../platform\service\sleeptimer\src; ../platform\bootloader\api; ../platform\bootloader; ../app\bluetooth\common\util; ../platform\halconfig\inc\hal-config; ../hardware\kit\common\halconfig
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: soc-empty.bin
  ILINK.IlinkOutputFile: soc-empty.out
  ILINK.IlinkIcfFile: ../efr32bg13p632f512gm48.icf
  ILINK.IlinkExtraOptions: --keep __iar_program_start; --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  group (top)
    ../: main.c app.c application_properties.c init_mcu.c init_board.c init_app.c pti.c gatt_db.c
    ../platform/Device/SiliconLabs/EFR32BG13P/Source/: system_efr32bg13p.c
    ../hardware/kit/common/drivers/: mx25flash_spi.c retargetserial.c retargetio.c i2cspm.c
    ../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_system.c em_gpio.c em_i2c.c em_rmu.c em_rtcc.c em_usart.c em_eusart.c em_msc.c em_timer.c em_burtc.c em_cryotimer.c em_crypto.c em_se.c
    ../platform/emdrv/sleep/src/: sleep.c
    ../platform/emdrv/nvm3/src/: nvm3_default.c nvm3_hal_flash.c nvm3_lock.c
    ../platform/Device/SiliconLabs/EFR32BG13P/Source/IAR/: startup_efr32bg13p.c
    ../platform/service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_rtcc.c
    ../app/bluetooth/common/util/: infrastructure.c
    ../hardware/kit/common/bsp/: bsp_stk.c
  group gattdb
    ../: gatt.xml
  group lib
    ../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg13_iar_release.a
    ../platform/emdrv/nvm3/lib/: libnvm3_CM4_iar.a
    ../protocol/bluetooth/lib/EFR32BG13P/IAR/: libpsstore.a libbluetooth.a libmbedtls.a binapploader.o
