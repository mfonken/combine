# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG13P632F512GM48 SiliconLaboratories EFR32BG13P632F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32BG13P632F512GM48; NVM3_DEFAULT_NVM_SIZE=24576; HAL_CONFIG=1; __STACK_SIZE=0x800; __StackLimit=0x20000000
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: ..; ../.; ../platform\emdrv\tempdrv\inc; ../platform\emdrv\sleep\inc; ../platform\emdrv\common\inc; ../platform\emlib\inc; ../platform\common\inc; ../platform\service\sleeptimer\inc; ../platform\service\sleeptimer\src; ../platform\bootloader\api; ../platform\CMSIS\Include; ../platform\Device\SiliconLabs\EFR32BG13P\Include; ../platform\emdrv\uartdrv\inc; ../platform\emdrv\gpiointerrupt\inc; ../platform\emdrv\nvm3\inc; ../protocol\bluetooth\ble_stack\inc\common; ../protocol\bluetooth\ble_stack\inc\soc; ../platform\service\sleeptimer\config; ../hardware\kit\common\drivers; ../hardware\kit\common\bsp; ../hardware\kit\EFR32BG13_BRD4104A\config; ../platform\micrium_os; ../platform\micrium_os\bsp\siliconlabs\generic\include; ../platform\micrium_os\common\include; ../platform\micrium_os\common\source\collections; ../platform\micrium_os\common\source\common; ../platform\micrium_os\common\source\kal; ../platform\micrium_os\common\source\lib; ../platform\micrium_os\common\source\logging; ../platform\micrium_os\common\source\platform_mgr; ../platform\micrium_os\common\source\rtos; ../platform\micrium_os\common\source\preprocessor; ../platform\micrium_os\common\source\ring_buf; ../platform\micrium_os\cpu\include; ../platform\micrium_os\kernel\source; ../platform\micrium_os\kernel\include; ../platform\micrium_os\ports\source\iar; ../app\bluetooth\common\util; ../platform\halconfig\inc\hal-config; ../hardware\kit\common\halconfig; ../platform\radio\rail_lib\common; ../platform\radio\rail_lib\chip\efr32\efr32xg1x; ../platform\radio\rail_lib\protocol\ble; ../platform\radio\rail_lib\protocol\ieee802154
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: soc-thermometer-rtos.bin
  ILINK.IlinkOutputFile: soc-thermometer-rtos.out
  ILINK.IlinkIcfFile: ../efr32bg13p632f512gm48.icf
  ILINK.IlinkExtraOptions: --keep __iar_program_start; --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  group (top)
    ../: main.c application_properties.c init_mcu.c init_board.c init_app.c pti.c gatt_db.c
    ../platform/emlib/src/: em_assert.c em_cmu.c em_crypto.c em_gpio.c em_i2c.c em_msc.c em_rmu.c em_rtcc.c em_rtc.c em_usart.c em_system.c em_eusart.c em_core.c em_emu.c em_timer.c em_burtc.c em_cryotimer.c em_se.c
    ../platform/common/src/: sl_slist.c
    ../platform/service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_rtc.c sl_sleeptimer_hal_rtcc.c
    ../hardware/kit/common/bsp/: bsp_stk.c bsp_stk_leds.c
    ../platform/Device/SiliconLabs/EFR32BG13P/Source/IAR/: startup_efr32bg13p.c
    ../platform/Device/SiliconLabs/EFR32BG13P/Source/: system_efr32bg13p.c
    ../platform/emdrv/sleep/src/: sleep.c
    ../platform/emdrv/nvm3/src/: nvm3_default.c nvm3_hal_flash.c nvm3_lock.c
    ../hardware/kit/common/drivers/: udelay.c mx25flash_spi.c
    ../protocol/bluetooth/ble_stack/src/soc/: rtos_bluetooth.c
    ../platform/micrium_os/bsp/siliconlabs/generic/source/: bsp_os.c bsp_cpu.c
    ../platform/micrium_os/common/source/collections/: bitmap.c map.c slist.c
    ../platform/micrium_os/common/source/common/: common.c
    ../platform/micrium_os/common/source/kal/: kal_kernel.c
    ../platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../platform/micrium_os/common/source/platform_mgr/: platform_mgr.c
    ../platform/micrium_os/common/source/rtos/: rtos_err_str.c
    ../platform/micrium_os/cpu/source/: cpu_core.c
    ../platform/micrium_os/kernel/source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_time.c os_tmr.c os_var.c
    ../platform/micrium_os/ports/source/iar/: armv7m_cpu_c.c armv7m_os_cpu_c.c armv7m_cpu_a.asm armv7m_os_cpu_a.asm
    ../app/bluetooth/common/util/: infrastructure.c
  group gattdb
    ../: gatt.xml
  group lib
    ../platform/emdrv/nvm3/lib/: libnvm3_CM4_iar.a
    ../protocol/bluetooth/lib/EFR32BG13P/IAR/: libpsstore.a libbluetooth.a libmbedtls.a binapploader.o
    ../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg13_iar_release.a
