# IAR project Backup (2) of rho_mod_v6.ewp, settings and files
configuration rho_mod_v6 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G431xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ..\Src\master; ..\Src\rho; ..\Src\rho\types; ..\Src\rho\core; ..\Src\rho\psm; ..\Src\master\platforms; ..\Src\master\OV9712
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rho_mod_v6.hex
  ILINK.IlinkOutputFile: rho_mod_v6.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c stm32g4xx_hal_msp.c stm32g4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group master
    ../Src/master/: global_config.h global_types.h master.c master.h master_interface.h platform.c platform.h printers.c printers.h resources.h system.c system.h
  group master/OV9712
    ../Src/master/OV9712/: OV9712.c OV9712.h OV9712_calc.h OV9712_regs.h
  group master/platforms
    ../Src/master/platforms/: platform_interface_master.h stm32_interface.c stm32_interface.h
  group rho
    ../Src/rho/: rho_config.h rho_global.h rho_master.h rho_packet.h
  group rho/core
    ../Src/rho/core/: rho_core.c rho_core.h rho_deco.c rho_deco.h rho_structure.h rho_utility.c rho_utility.h
  group rho/types
    ../Src/rho/types/: kalman.c kalman.h pid.c pid.h rho_types.h
