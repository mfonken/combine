<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\rho_mod_v5.ewp</path>
  </project>
  <batchBuild />
</workspace>
