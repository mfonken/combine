# IAR project rho_mod_v4.ewp, settings and files
configuration rho_mod_v4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L432KB ST STM32L432KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L432xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../../../../freeze/rho; ../../../../freeze/rho/cores; ../../../../freeze/rho/state_control; ../../../../freeze/rho/types
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rho_mod_v4.srec
  ILINK.IlinkOutputFile: rho_mod_v4.out
  ILINK.IlinkIcfFile: stm32l432xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l432xx.s
  group Application/User
    ../Src/: main.c master.c master.h printers.c printers.h stm32_rho_interface.h stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/User/OV9712
    ../Src/: OV9712.c OV9712.h OV9712_regs.h
  group Application/User/Rho
    ../../../../freeze/rho/: global_config.h rho_master.h
  group Application/User/Rho/core
    ../../../../freeze/rho/core/: rho_client.c rho_client.h rho_utility.c rho_utility.h
  group Application/User/Rho/state_control
    ../../../../freeze/rho/state_control/: state_machine_utility.h
  group Application/User/Rho/types
    ../../../../freeze/rho/types/: rho_kalman.c rho_kalman.h rho_types.h
    ../../../../freeze/rho/state_control/: state_machine_utility.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
