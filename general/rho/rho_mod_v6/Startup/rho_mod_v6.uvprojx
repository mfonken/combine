# Keil uVision project rho_mod_v6.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rho_mod_v6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G431KBUx/STCubeGenerated/Src/: main.c stm32g4xx_it.c
    ./RTE/Device/STM32G431KBUx/STCubeGenerated/Inc/: stm32g4xx_it.h
software components: CMSIS:CORE 5.1.1, USB:CORE 6.11.0, USB:Device 6.11.0, USB:Device:HID 6.11.0, Device:STM32Cube HAL 1.4.0
