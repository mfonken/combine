# IAR project rho_mod_v5.ewp, settings and files
configuration rho_mod_v6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L432KB ST STM32L432KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L432xx; __STM32__; __RHO__; __OV9712__
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Src\master; ..\Src\rho; ..\Src\rho\types; ..\Src\rho\core; ..\Src\rho\psm; ..\Src\master\platforms; ..\Src\master\OV9712
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rho_mod_v6.hex
  ILINK.IlinkOutputFile: rho_mod_v6.out
  ILINK.IlinkIcfFile: stm32l432xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l432xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Application/User/Master
    ../Src/master/: global_config.h global_types.h master.c master.h master_interface.h platform.c platform.h system.c system.h
  group Application/User/Platform
    ../Src/master/platforms/: platform_interface_master.h stm32_interface.c stm32_interface.h
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/User/Resources
    ../Src/master/: printers.c printers.h resources.h
  group Application/User/Rho
    ../Src/rho/: rho_config.h rho_global.h rho_master.h
  group Application/User/Rho/Core
    ../Src/rho/core/: rho_deco.c rho_deco.h rho_core.c rho_core.h rho_structure.h rho_utility.c rho_utility.h
  group Application/User/Rho/State
    ../Src/rho/psm/: control_structures.h control_types.h fsm.c fsm.h fsm_support.h kumaraswamy.h
  group Application/User/Rho/Types
    ../Src/rho/types/: rho_kalman.c rho_kalman.h rho_pid.c rho_pid.h rho_types.h
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/OV9712
    ../Src/master/OV9712/: OV9712.c OV9712.h OV9712_calc.h OV9712_regs.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
