# Keil uVision project rho_mod_v1.uvprojx, settings and files
target rho_mod_v3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L432KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: rho_mod_v3
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L432xx
  c include: ../Inc;                                                                                                    ../Drivers/STM32L4xx_HAL_Driver/Inc;                                                                                                    ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                                                                                                    ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                                                                                                    ../Drivers/CMSIS/Include
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l432xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_flash.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c master.h master.c OV9712.h OV9712.c OV9712_regs.h
  group Rho
    ../Src/rho/: rho.s rho_kalman.c rho_kalman.h rho_utility.c rho_utility.h rho_types.h
    ../Src/Rho/: state_machine_utility.c state_machine_utility.h
software components: CMSIS:CORE 4.3.0
